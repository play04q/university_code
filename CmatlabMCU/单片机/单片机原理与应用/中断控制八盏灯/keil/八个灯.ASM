ORG 0000H
	AJMP START
ORG 0003H
	AJMP INTR0
ORG 0013H
	AJMP INTR1
	START:MOV IE,#85H
	MOV IP,#04H
	MOV TCON,#00H
	MOV SP,#60H
	MOV P0,#0FFH
	MOV P1,#0FFH
	MOV P3,#0FFH
	MOV R0, #00H
	MOV A,#00H
	LP1:MOV P0,A
	LCALL DELAY
	CPL A
	SJMP LP1
	INTR0:PUSH ACC
	PUSH PSW
	INC R0
	MOV A,#01H
	ANL A,R0
	JNB PSW.0,DOUBLE
	MOV P0,#00H
	MOV A,#0FH
	MOV R4,#03H
	SINGLE:MOV P0,A
	LCALL DELAY
	SWAP A
	DJNZ R4,SINGLE
	AJMP EXIT
	DOUBLE:MOV P0,#0FFH
	MOV R1,#02H
	DOUBLE1:MOV A,#0FEH
	MOV R2,#08H
	LP2:MOV P0,A
	RL A
	LCALL DELAY
	DJNZ R2,LP2
	MOV A,#07H
	MOV R2,#08H
	LP3:MOV P0,A
	LCALL DELAY
	RR A
	DJNZ R2,LP3
	DJNZ R1,DOUBLE1
	EXIT:NOP
	POP PSW
	POP ACC
	RETI
	INTR1:CLR P1.0
	LCALL DELAY
	SETB P1.0
	RETI
	DELAY:MOV R7,#20
	DELA1:MOV R6,#20
	DELA2:MOV R5,#248
	DJNZ R5,$
	DJNZ R6,DELA2
	DJNZ R7,DELA1
	RET
END
	
	
	