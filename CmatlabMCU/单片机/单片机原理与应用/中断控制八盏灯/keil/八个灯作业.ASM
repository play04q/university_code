ORG 0000H
	AJMP START
ORG 0003H
	AJMP INTR0
ORG 0013H
	AJMP INTR1
	START:MOV IE,#85H
	MOV IP,#01H
	MOV TCON,#00H
	MOV SP,#60H
	MOV P0,#0FFH
	MOV P3,#0FFH
	MOV R0, #00H
	MOV A,#00H
	LP1:MOV P0,A
	LCALL DELAY
	CPL A
	SJMP LP1
	INTR1:PUSH ACC
	PUSH PSW
	INC R0
	MOV P0,#00H
	MOV A,#0FFH
	MOV R4,#03H
	SINGLE:MOV P0,A
	LCALL DELAY
	SWAP A
	DJNZ R4,SINGLE
	AJMP EXIT
	LP3:MOV P0,A
	LCALL DELAY
	RR A
	DJNZ R2,LP3
	EXIT:NOP
	POP PSW
	POP ACC
	RETI
	INTR0:MOV P0,#00H
	LCALL DELAY
	MOV P0,#0FFH
	MOV R4,#05H
	RETI
	DELAY:MOV R7,#20
	DELA1:MOV R6,#20
	DELA2:MOV R5,#248
	DJNZ R5,$
	DJNZ R6,DELA2
	DJNZ R7,DELA1
	RET
END
