# Keil uVision project 作业点三个灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 作业点三个灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 作业点三个灯改.C
