ORG 0000H
	LJMP MAIN
	ORG 0100H
	MAIN: MOV TMOD, #01H
	MOV TH0, #3CH
	MOV TL0, #0B0H
	SETB TR0
	SETB P1.0
	CLR P1.1
	CLR P1.2
	MOV R7, #00
	LOOP: JNB TF0, LOOP
	MOV TH0, #3CH
	MOV TL0, #0B0H
	INC R7
	CLR TF0
	CJNE R7, #20,LOOP
	MOV R7, #00
	CPL P1.0
	CPL P1.1
	CJNE R7, #20,LOOP
	MOV R7, #00
	CPL P1.2
	CPL P1.1
	CJNE R7, #20,LOOP
	MOV R7, #00
	CPL P1.0
	CPL P1.2
	AJMP LOOP
END