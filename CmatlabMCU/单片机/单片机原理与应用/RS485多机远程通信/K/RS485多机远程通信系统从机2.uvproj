# Keil uVision project RS485多机远程通信系统从机2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: RS485多机远程通信系统从机2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: RS485多机远程通信系统从机2.c
