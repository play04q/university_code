ORG 0000H
	AJMP MAIN
ORG 000BH
	AJMP LIGHT
ORG 0030H
	MAIN: MOV SP,#60H
	MOV TMOD,#01H
	MOV TH0,#3CH
	MOV TL0,#0B0H
	SETB EA
	SETB ET0
	MOV R7,#20
	SETB P0.0
	CLR P0.1
	SETB TR0
	SJMP $
ORG 0100H
	LIGHT:MOV TH0,#3CH
	MOV TL0,#0B0H
	DJNZ R7,EXIT
	MOV R7,#20
	CPL P0.0
	CPL P0.1
	EXIT:RETI
END