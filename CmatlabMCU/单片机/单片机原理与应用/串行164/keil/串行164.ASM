ORG 00H
	AJMP START
ORG 0003H
	AJMP INT
	START: MOV SP,#60H
	MOV SCON,#00H
	SETB IT0
	SETB EA
	SETB EX0
	MOV DPTR,#TABLE
	MOV SBUF,#0FFH
	LP:CLR TI
	AJMP LP
	INT:MOV A,#00H
	MOVC A,@A + DPTR
	MOV SBUF,A
	LP1:JBC TI,LP1
	INC DPTR
	MOV A,#00H
	MOVC A,@A + DPTR
	CJNE A,#1BH,LP2
	MOV DPTR,#TABLE
	LP2:NOP
	RETI
	TABLE:DB 0FEH,0FDH,0FBH,0F7H
		DB 0EFH,0DFH,0BFH,7FH,1BH
		END